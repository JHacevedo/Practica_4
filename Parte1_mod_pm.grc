options:
  parameters:
    generate_options: qt_gui
    id: Modulacion_PM
    output_language: python
    title: Modulación PM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amp portadora
    orient: Qt.Horizontal
    start: '0'
    step: '1e-6'
    stop: '35'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amp mensaje
    orient: Qt.Horizontal
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    orient: Qt.Horizontal
    start: 1e3
    step: '100'
    stop: 20e3
    value: 1e3
  states: {}
- name: kp
  id: variable_qtgui_range
  parameters:
    label: kp
    orient: Qt.Horizontal
    start: '0'
    step: '1e-6'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: Envolvente_Compleja_PM_0
  id: Envolvente_Compleja_PM
  parameters:
    Ac: '100e-3'
    Kp: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: 1e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [Envolvente_Compleja_PM_0, '0', qtgui_freq_sink_x_0, '0']
- [Envolvente_Compleja_PM_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', Envolvente_Compleja_PM_0, '0']

metadata:
  file_format: 1
